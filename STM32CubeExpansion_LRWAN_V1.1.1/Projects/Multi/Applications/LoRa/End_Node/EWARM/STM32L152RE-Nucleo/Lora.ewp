# IAR project Lora.ewp, settings and files
configuration sx1276mb1mas (ARM, debug)
  General.OGChipSelectEditMenu: STM32L152RE ST STM32L152RE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32L152xE; USE_STM32L1XX_NUCLEO; USE_HAL_DRIVER; REGION_EU868
  ICCARM.CCIncludePath2: ../../inc; ../../../../../../../Drivers/CMSIS/Device/ST/STM32L1xx/Include; ../../../../../../../Drivers/BSP/STM32L1xx_Nucleo; ../../../../../../../Drivers/STM32L1xx_HAL_Driver/Inc; ../../../../../../../Drivers/CMSIS/Include; ../../../../../../../Middlewares/Third_Party/Lora/Crypto; ../../../../../../../Middlewares/Third_Party/Lora/Mac; ../../../../../../../Middlewares/Third_Party/Lora/Phy; ../../../../../../../Middlewares/Third_Party/Lora/Utilities; ../../../../../../../Drivers/BSP/X_NUCLEO_IKS01A1; ../../../../../../../Drivers/BSP/X_NUCLEO_IKS01A2; ../../../../../../../Drivers/BSP/Components/Common; ../../../../../../../Drivers/BSP/Components/hts221; ../../../../../../../Drivers/BSP/Components/lps22hb; ../../../../../../../Drivers/BSP/Components/lps25hb; ../../../../../../../Drivers/BSP/Components/sx1276; ../../../../../../../Middlewares/Third_Party/Lora/Core; ../../../../../../../Drivers/BSP/sx1276mb1mas; ..\..\..\..\..\..\..\Drivers\BSP\Components\lsm6dsl; ..\..\..\..\..\..\..\Drivers\BSP\Components\lsm303agr
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Lora.bin
  ILINK.IlinkOutputFile: sx1276mb1mas.out
  ILINK.IlinkIcfFile: stm32l152xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration sx1272mb2das (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ../../inc; ../../../../../../../Drivers/CMSIS/Device/ST/STM32L1xx/Include; ../../../../../../../Drivers/BSP/STM32L1xx_Nucleo; ../../../../../../../Drivers/STM32L1xx_HAL_Driver/Inc; ../../../../../../../Drivers/CMSIS/Include; ../../../../../../../Middlewares/Third_Party/Lora/Crypto; ../../../../../../../Middlewares/Third_Party/Lora/Mac; ../../../../../../../Middlewares/Third_Party/Lora/Phy; ../../../../../../../Middlewares/Third_Party/Lora/Utilities; ../../../../../../../Drivers/BSP/X_NUCLEO_IKS01A1; ../../../../../../../Drivers/BSP/X_NUCLEO_IKS01A2; ../../../../../../../Drivers/BSP/Components/Common; ../../../../../../../Drivers/BSP/Components/hts221; ../../../../../../../Drivers/BSP/Components/lps22hb; ../../../../../../../Drivers/BSP/Components/lps25hb; ../../../../../../../Drivers/BSP/Components/sx1272; ../../../../../../../Middlewares/Third_Party/Lora/Core; ../../../../../../../Drivers/BSP/sx1272mb2das
  ILINK.IlinkOutputFile: sx1272mb2das.out
configuration sx1276mb1las (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ../../inc; ../../../../../../../Drivers/CMSIS/Device/ST/STM32L1xx/Include; ../../../../../../../Drivers/BSP/STM32L1xx_Nucleo; ../../../../../../../Drivers/STM32L1xx_HAL_Driver/Inc; ../../../../../../../Drivers/CMSIS/Include; ../../../../../../../Middlewares/Third_Party/Lora/Crypto; ../../../../../../../Middlewares/Third_Party/Lora/Mac; ../../../../../../../Middlewares/Third_Party/Lora/Phy; ../../../../../../../Middlewares/Third_Party/Lora/Utilities; ../../../../../../../Drivers/BSP/X_NUCLEO_IKS01A1; ../../../../../../../Drivers/BSP/X_NUCLEO_IKS01A2; ../../../../../../../Drivers/BSP/Components/Common; ../../../../../../../Drivers/BSP/Components/hts221; ../../../../../../../Drivers/BSP/Components/lps22hb; ../../../../../../../Drivers/BSP/Components/lps25hb; ../../../../../../../Drivers/BSP/Components/sx1276; ../../../../../../../Middlewares/Third_Party/Lora/Core; ../../../../../../../Drivers/BSP/sx1276mb1las
  ILINK.IlinkOutputFile: sx1276mb1las.out
configuration LRWAN-NS1 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32L152xE; USE_STM32L1XX_NUCLEO; USE_HAL_DRIVER; REGION_EU433; LRWAN_NS1
  ICCARM.CCIncludePath2: ../../inc; ../../../../../../../Drivers/CMSIS/Device/ST/STM32L1xx/Include; ../../../../../../../Drivers/BSP/STM32L1xx_Nucleo; ../../../../../../../Drivers/STM32L1xx_HAL_Driver/Inc; ../../../../../../../Drivers/CMSIS/Include; ../../../../../../../Middlewares/Third_Party/Lora/Crypto; ../../../../../../../Middlewares/Third_Party/Lora/Mac; ../../../../../../../Middlewares/Third_Party/Lora/Phy; ../../../../../../../Middlewares/Third_Party/Lora/Utilities; ../../../../../../../Drivers/BSP/Components/Common; ../../../../../../../Drivers/BSP/Components/hts221; ../../../../../../../Drivers/BSP/Components/lps22hb; ../../../../../../../Drivers/BSP/Components/lps25hb; ../../../../../../../Drivers/BSP/Components/sx1276; ../../../../../../../Middlewares/Third_Party/Lora/Core; ../../../../../../../Drivers/BSP/LRWAN_NS1
  ILINK.IlinkOutputFile: LRWAN-NS1.out
  group Doc
    ../../: readme.txt
  group Drivers/BSP/Components
    ../../../../../../../Drivers/BSP/Components/hts221/: HTS221_Driver.c HTS221_Driver_HL.c
    ../../../../../../../Drivers/BSP/Components/lps22hb/: LPS22HB_Driver.c LPS22HB_Driver_HL.c
    ../../../../../../../Drivers/BSP/Components/lps25hb/: LPS25HB_Driver.c LPS25HB_Driver_HL.c
    ../../../../../../../Drivers/BSP/Components/lsm303agr/: LSM303AGR_ACC_driver.c LSM303AGR_ACC_driver_HL.c
    ../../../../../../../Drivers/BSP/Components/lsm6dsl/: LSM6DSL_ACC_GYRO_driver.c LSM6DSL_ACC_GYRO_driver_HL.c
    ../../../../../../../Drivers/BSP/Components/sx1272/: sx1272.c
    ../../../../../../../Drivers/BSP/Components/sx1276/: sx1276.c
  group Drivers/BSP/LRWAN_NS1
    ../../../../../../../Drivers/BSP/LRWAN_NS1/: lrwan_ns1.c lrwan_ns1_humidity.c lrwan_ns1_pressure.c lrwan_ns1_temperature.c sx1276_lrwan_ns1.c
  group Drivers/BSP/STM32L1xx_Nucleo
    ../../../../../../../Drivers/BSP/STM32L1xx_Nucleo/: stm32l1xx_nucleo.c
  group Drivers/BSP/sx1272mb2das
    ../../../../../../../Drivers/BSP/sx1272mb2das/: sx1272mb2das.c
  group Drivers/BSP/sx1276mb1las
    ../../../../../../../Drivers/BSP/sx1276mb1las/: sx1276mb1las.c
  group Drivers/BSP/sx1276mb1mas
    ../../../../../../../Drivers/BSP/sx1276mb1mas/: sx1276mb1mas.c
  group Drivers/BSP/X_NUCLEO_IKS01A1
    ../../../../../../../Drivers/BSP/X_NUCLEO_IKS01A1/: x_nucleo_iks01a1.c x_nucleo_iks01a1_humidity.c x_nucleo_iks01a1_pressure.c x_nucleo_iks01a1_temperature.c
  group Drivers/BSP/X_NUCLEO_IKS01A2
    ../../../../../../../Drivers/BSP/X_NUCLEO_IKS01A2/: x_nucleo_iks01a2.c x_nucleo_iks01a2_accelero.c x_nucleo_iks01a2_humidity.c x_nucleo_iks01a2_pressure.c x_nucleo_iks01a2_temperature.c
  group Drivers/CMSIS
    ../../../../../../../Drivers/CMSIS/Device/ST/STM32L1xx/Source/Templates/: system_stm32l1xx.c
  group Drivers/STM32L1xx_HAL_Driver
    ../../../../../../../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal.c stm32l1xx_hal_adc.c stm32l1xx_hal_adc_ex.c stm32l1xx_hal_cortex.c stm32l1xx_hal_dma.c stm32l1xx_hal_gpio.c stm32l1xx_hal_i2c.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_rtc.c stm32l1xx_hal_rtc_ex.c stm32l1xx_hal_spi.c stm32l1xx_hal_spi_ex.c stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_uart.c
  group Middlewares/Lora/Core
    ../../../../../../../Middlewares/Third_Party/Lora/Core/: lora.c
  group Middlewares/Lora/Crypto
    ../../../../../../../Middlewares/Third_Party/Lora/Crypto/: aes.c cmac.c
  group Middlewares/Lora/Mac
    ../../../../../../../Middlewares/Third_Party/Lora/Mac/: LoRaMac.c LoRaMacCrypto.c
  group Middlewares/Lora/Mac/Region
    ../../../../../../../Middlewares/Third_Party/Lora/Mac/region/: Region.c RegionAS923.c RegionAU915.c RegionCN470.c RegionCN779.c RegionCommon.c RegionEU433.c RegionEU868.c RegionIN865.c RegionKR920.c RegionUS915-Hybrid.c RegionUS915.c
  group Middlewares/Lora/Utilities
    ../../../../../../../Middlewares/Third_Party/Lora/Utilities/: delay.c low_power.c timeServer.c utilities.c
  group Projects/End_Node
    ../../src/: bsp.c debug.c hw_gpio.c hw_rtc.c hw_spi.c main.c stm32l1xx_hal_msp.c stm32l1xx_hw.c stm32l1xx_it.c vcom.c
  group Projects/EWARM
    ./: startup_stm32l152xe.s
