# IAR project SubGHz_Phy_PingPong.ewp, settings and files
configuration sx1276mb1mas (ARM, debug)
  General.OGChipSelectEditMenu: STM32L476RG ST STM32L476RG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32L476xx; SX1276MB1MAS
  ICCARM.CCIncludePath2: ../SubGHz_Phy/App; ../SubGHz_Phy/Target; ../Core/Inc; ../../../../../../Utilities/misc; ../../../../../../Utilities/timer; ../../../../../../Utilities/trace/adv_trace; ../../../../../../Utilities/lpm/tiny_lpm; ../../../../../../Utilities/sequencer; ../../../../../../Drivers/BSP/STM32L4xx_Nucleo; ../../../../../../Drivers/BSP/sx1276mb1mas; ../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc; ../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Middlewares/Third_Party/SubGHz_Phy; ../../../../../../Middlewares/Third_Party/SubGHz_Phy/sx1276
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SubGHz_Phy_PingPong.bin
  ILINK.IlinkOutputFile: sx1276mb1mas.out
  ILINK.IlinkIcfFile: stm32l476xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration sx1272mb2das (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32L476xx; SX1272MB2DAS
  ICCARM.CCIncludePath2: ../SubGHz_Phy/App; ../SubGHz_Phy/Target; ../Core/Inc; ../../../../../../Utilities/misc; ../../../../../../Utilities/timer; ../../../../../../Utilities/trace/adv_trace; ../../../../../../Utilities/lpm/tiny_lpm; ../../../../../../Utilities/sequencer; ../../../../../../Drivers/BSP/STM32L4xx_Nucleo; ../../../../../../Drivers/BSP/sx1272mb2das; ../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc; ../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Middlewares/Third_Party/SubGHz_Phy; ../../../../../../Middlewares/Third_Party/SubGHz_Phy/sx1272
  ILINK.IlinkOutputFile: sx1272mb2das.out
configuration sx1276mb1las (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32L476xx; SX1276MB1LAS
  ICCARM.CCIncludePath2: ../SubGHz_Phy/App; ../SubGHz_Phy/Target; ../Core/Inc; ../../../../../../Utilities/misc; ../../../../../../Utilities/timer; ../../../../../../Utilities/trace/adv_trace; ../../../../../../Utilities/lpm/tiny_lpm; ../../../../../../Utilities/sequencer; ../../../../../../Drivers/BSP/STM32L4xx_Nucleo; ../../../../../../Drivers/BSP/sx1276mb1las; ../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc; ../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Middlewares/Third_Party/SubGHz_Phy; ../../../../../../Middlewares/Third_Party/SubGHz_Phy/sx1276
  ILINK.IlinkOutputFile: sx1276mb1las.out
configuration sx1261dvk1bas (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32L476xx; SX1261DVK1BAS
  ICCARM.CCIncludePath2: ../SubGHz_Phy/App; ../SubGHz_Phy/Target; ../Core/Inc; ../../../../../../Utilities/misc; ../../../../../../Utilities/timer; ../../../../../../Utilities/trace/adv_trace; ../../../../../../Utilities/lpm/tiny_lpm; ../../../../../../Utilities/sequencer; ../../../../../../Drivers/BSP/STM32L4xx_Nucleo; ../../../../../../Drivers/BSP/SX1261DVK1BAS; ../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc; ../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Middlewares/Third_Party/SubGHz_Phy; ../../../../../../Middlewares/Third_Party/SubGHz_Phy/sx126x
configuration sx1262dvk1cas (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32L476xx; SX1262DVK1CAS
  ICCARM.CCIncludePath2: ../SubGHz_Phy/App; ../SubGHz_Phy/Target; ../Core/Inc; ../../../../../../Utilities/misc; ../../../../../../Utilities/timer; ../../../../../../Utilities/trace/adv_trace; ../../../../../../Utilities/lpm/tiny_lpm; ../../../../../../Utilities/sequencer; ../../../../../../Drivers/BSP/STM32L4xx_Nucleo; ../../../../../../Drivers/BSP/SX1262DVK1CAS; ../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc; ../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Middlewares/Third_Party/SubGHz_Phy; ../../../../../../Middlewares/Third_Party/SubGHz_Phy/sx126x
configuration sx1262dvk1das (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32L476xx; SX1262DVK1DAS
  ICCARM.CCIncludePath2: ../SubGHz_Phy/App; ../SubGHz_Phy/Target; ../Core/Inc; ../../../../../../Utilities/misc; ../../../../../../Utilities/timer; ../../../../../../Utilities/trace/adv_trace; ../../../../../../Utilities/lpm/tiny_lpm; ../../../../../../Utilities/sequencer; ../../../../../../Drivers/BSP/STM32L4xx_Nucleo; ../../../../../../Drivers/BSP/SX1262DVK1DAS; ../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc; ../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Middlewares/Third_Party/SubGHz_Phy; ../../../../../../Middlewares/Third_Party/SubGHz_Phy/sx126x
  group Application/App
    ../SubGHz_Phy/App/: app_subghz_phy.c subghz_phy_app.c
  group Application/Core
    ../Core/Src/: dma.c main.c rtc.c rtc_if.c stm32_lpm_if.c stm32l4xx_hal_msp.c stm32l4xx_it.c sys_app.c sys_debug.c usart.c usart_if.c
  group Application/EWARM
    ./: startup_stm32l476xx.s
  group Application/Target
    ../SubGHz_Phy/Target/: nucleo_l476rg_bus.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32L4xx_Nucleo
    ../../../../../../Drivers/BSP/STM32L4xx_Nucleo/: stm32l4xx_nucleo.c
  group Drivers/BSP/sx1261dvk1bas
    ../../../../../../Drivers/BSP/SX1261DVK1BAS/: sx1261dvk1bas.c
  group Drivers/BSP/sx1262dvk1cas
    ../../../../../../Drivers/BSP/SX1262DVK1CAS/: sx1262dvk1cas.c
  group Drivers/BSP/sx1262dvk1das
    ../../../../../../Drivers/BSP/SX1262DVK1DAS/: sx1262dvk1das.c
  group Drivers/BSP/sx1272mb2das
    ../../../../../../Drivers/BSP/sx1272mb2das/: sx1272mb2das.c
  group Drivers/BSP/sx1276mb1las
    ../../../../../../Drivers/BSP/sx1276mb1las/: sx1276mb1las.c
  group Drivers/BSP/sx1276mb1mas
    ../../../../../../Drivers/BSP/sx1276mb1mas/: sx1276mb1mas.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_exti.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
  group Middlewares/SubGHz_Phy
    ../../../../../../Middlewares/Third_Party/SubGHz_Phy/sx126x/: radio.c sx126x.c
    ../../../../../../Middlewares/Third_Party/SubGHz_Phy/sx1272/: sx1272.c
    ../../../../../../Middlewares/Third_Party/SubGHz_Phy/sx1276/: sx1276.c
  group Utilities
    ../../../../../../Utilities/trace/adv_trace/: stm32_adv_trace.c
    ../../../../../../Utilities/lpm/tiny_lpm/: stm32_lpm.c
    ../../../../../../Utilities/misc/: stm32_mem.c stm32_systime.c stm32_tiny_vsnprintf.c
    ../../../../../../Utilities/sequencer/: stm32_seq.c
    ../../../../../../Utilities/timer/: stm32_timer.c
