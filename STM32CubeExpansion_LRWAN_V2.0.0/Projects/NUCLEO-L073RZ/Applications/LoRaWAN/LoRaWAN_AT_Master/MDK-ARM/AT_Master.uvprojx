# Keil uVision project AT_Master.uvprojx, settings and files
target I_NUCLEO_LRWAN1 (6120000::V6.12::.\ARMCLANG)
  device: STM32L073RZTx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.1.0
  cpu: IROM(0x08000000-0x802FFFF) IRAM(0x20000000-0x20004FFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: I_NUCLEO_LRWAN1
  AfterMake: fromelf #L --bin --output=$L@L.bin
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32L073xx,USE_BAND_868,USE_STM32L0XX_NUCLEO,USE_I_NUCLEO_LRWAN1
  c include: ../Core/Inc;../LoRaWAN/App;../../../../../../Drivers/STM32L0xx_HAL_Driver/Inc;../../../../../../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32L0xx/Include;../../../../../../Drivers/BSP/Components/Common;../../../../../../Drivers/BSP/Components/hts221;../../../../../../Drivers/BSP/Components/lps25hb;../../../../../../Drivers/BSP/Components/lps22hb;../../../../../../Drivers/BSP/MDM32L07X01;../../../../../../Drivers/BSP/I_NUCLEO_LRWAN1;../../../../../../Drivers/BSP/STM32L0xx_Nucleo;../../../../../../Utilities/lpm/tiny_lpm;../../../../../../Utilities/misc;../../../../../../Utilities/timer
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/App
    ../LoRaWAN/App/: app_master.c lora_driver.c master_app.c
  group Application/Core
    ../Core/Src/: adc.c adc_if.c ee.c main.c rtc.c rtc_if.c stm32_lpm_if.c stm32l0xx_hal_msp.c stm32l0xx_it.c sys_app.c sys_debug.c sys_sensors.c usart.c
  group Application/MDK-ARM
    ./: startup_stm32l073xx.s
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/hts221/: HTS221_Driver.c HTS221_Driver_HL.c
    ../../../../../../Drivers/BSP/Components/lps22hb/: LPS22HB_Driver.c LPS22HB_Driver_HL.c
    ../../../../../../Drivers/BSP/Components/lps25hb/: LPS25HB_Driver.c LPS25HB_Driver_HL.c
  group Drivers/BSP/I_NUCLEO_LRWAN1
    ../../../../../../Drivers/BSP/I_NUCLEO_LRWAN1/: i_nucleo_lrwan1.c i_nucleo_lrwan1_humidity.c i_nucleo_lrwan1_pressure.c i_nucleo_lrwan1_temperature.c i_nucleo_lrwan1_wm_sg_sm_xx.c
  group Drivers/BSP/LRWAN_NS1
    ../../../../../../Drivers/BSP/LRWAN_NS1/: lrwan_ns1.c lrwan_ns1_atcmd.c lrwan_ns1_humidity.c lrwan_ns1_pressure.c lrwan_ns1_temperature.c
  group Drivers/BSP/MDM32L07X01
    ../../../../../../Drivers/BSP/MDM32L07X01/: atcmd.c
  group Drivers/BSP/MDM32WL
    ../../../../../../Drivers/BSP/MDM32WL/: mdm32wl_atcmd.c
  group Drivers/BSP/STM32L0xx_Nucleo
    ../../../../../../Drivers/BSP/STM32L0xx_Nucleo/: stm32l0xx_nucleo.c
  group Drivers/CMSIS
    ../../../../../../Drivers/CMSIS/Device/ST/STM32L0xx/Source/Templates/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../../../../../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c
  group Utilities
    ../../../../../../Utilities/lpm/tiny_lpm/: stm32_lpm.c
    ../../../../../../Utilities/misc/: stm32_mem.c stm32_tiny_sscanf.c stm32_tiny_vsnprintf.c
    ../../../../../../Utilities/sequencer/: stm32_seq.c
    ../../../../../../Utilities/timer/: stm32_timer.c
target MDM32L07X01 (6120000::V6.12::.\ARMCLANG)
  device: STM32L073RZTx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.1.0
  cpu: as above
  output: MDM32L07X01
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32L073xx,USE_BAND_868,USE_STM32L0XX_NUCLEO,USE_MDM32L07X01
  c include: ../Core/Inc;../LoRaWAN/App;../../../../../../Drivers/STM32L0xx_HAL_Driver/Inc;../../../../../../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32L0xx/Include;../../../../../../Drivers/BSP/Components/Common;../../../../../../Drivers/BSP/Components/hts221;../../../../../../Drivers/BSP/Components/lps25hb;../../../../../../Drivers/BSP/Components/lps22hb;../../../../../../Drivers/BSP/X_NUCLEO_IKS01A1;../../../../../../Drivers/BSP/X_NUCLEO_IKS01A2;../../../../../../Drivers/BSP/MDM32L07X01;../../../../../../Drivers/BSP/I_NUCLEO_LRWAN1;../../../../../../Drivers/BSP/STM32L0xx_Nucleo;../../../../../../Utilities/lpm/tiny_lpm;../../../../../../Utilities/misc;../../../../../../Utilities/timer
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
target LRWAN_NS1 (6120000::V6.12::.\ARMCLANG)
  device: STM32L073RZTx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.1.0
  cpu: as above
  output: LRWAN_NS1
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32L073xx,USE_BAND_868,USE_STM32L0XX_NUCLEO,USE_LRWAN_NS1,CMD_DEBUG
  c include: ../Core/Inc;../LoRaWAN/App;../../../../../../Drivers/STM32L0xx_HAL_Driver/Inc;../../../../../../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32L0xx/Include;../../../../../../Drivers/BSP/Components/Common;../../../../../../Drivers/BSP/Components/hts221;../../../../../../Drivers/BSP/Components/lps25hb;../../../../../../Drivers/BSP/Components/lps22hb;../../../../../../Drivers/BSP/LRWAN_NS1;../../../../../../Drivers/BSP/STM32L0xx_Nucleo;../../../../../../Utilities/lpm/tiny_lpm;../../../../../../Utilities/misc;../../../../../../Utilities/timer
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
target MDM32WL (6120000::V6.12::.\ARMCLANG)
  device: STM32L073RZTx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.1.0
  cpu: as above
  output: MDM32WL
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32L073xx,USE_BAND_868,USE_STM32L0XX_NUCLEO,USE_MDM32WL
  c include: ../Core/Inc;../LoRaWAN/App;../../../../../../Drivers/STM32L0xx_HAL_Driver/Inc;../../../../../../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32L0xx/Include;../../../../../../Drivers/BSP/Components/Common;../../../../../../Drivers/BSP/Components/hts221;../../../../../../Drivers/BSP/Components/lps25hb;../../../../../../Drivers/BSP/Components/lps22hb;../../../../../../Drivers/BSP/X_NUCLEO_IKS01A1;../../../../../../Drivers/BSP/X_NUCLEO_IKS01A2;../../../../../../Drivers/BSP/MDM32L07X01;../../../../../../Drivers/BSP/I_NUCLEO_LRWAN1;../../../../../../Drivers/BSP/STM32L0xx_Nucleo;../../../../../../Utilities/lpm/tiny_lpm;../../../../../../Utilities/misc;../../../../../../Utilities/timer;../../../../../../Drivers/BSP/MDM32WL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
software components: CMSIS:CORE 5.4.0
